# Keil uVision project inclinometer_dynamic.uvprojx, settings and files
target Inclinometer_dynamic (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: S32K144UAxxxLHx NXP
  pack: Keil.S32_SDK_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00007000) IRAM2(0x1FFF8000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Inclinometer_dynamic +hex
  BeforeMake: ..\keil_prebuild.bat
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: ENABLE_FPU,USING_OS_FREERTOS
  c include: ..\platform\devices\common;..\platform\devices;..\platform\devices\S32K144\include;..\platform\drivers\inc;..\platform\devices\S32K144\startup;..\Drivers\CMSIS\Include;..\Middlewares\Third_Party\FreeRTOS\Source\include;..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\Main;..\initcalls;..\rtos\osif;..\Generated_Code;..\platform\drivers\src\clock\S32K1xx;..\Drivers;..\APP;..\CMSIS-DSP\1.14.2\Include\dsp;..\CMSIS-DSP\1.14.2\Include;..\common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x7000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: ..\linker\S32K144_64_flash.sct
  group Startup
    ../Main/: main.c S32K144_it.c
    ../Initcalls/: init_calls.c
    ../platform/devices/S32K144/startup/armc/: startup_S32K144.S
    ../platform/devices/S32K144/startup/: system_S32K144.c
    ./: fast_memcpy.s
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Platform driver
    ../platform/drivers/src/lpuart/: lpuart_driver.c lpuart_hw_access.c lpuart_irq.c
    ../platform/drivers/src/clock/S32K1xx/: clock_S32K1xx.c
    ../platform/drivers/src/edma/: edma_driver.c edma_hw_access.c edma_irq.c
    ../rtos/osif/: osif_freertos.c
    ../platform/drivers/src/interrupt/: interrupt_manager.c
    ../platform/drivers/src/pins/: pins_driver.c pins_port_hw_access.c
    ../platform/drivers/src/lpi2c/: lpi2c_driver.c lpi2c_hw_access.c lpi2c_irq.c
    ../platform/drivers/src/lpspi/: lpspi_hw_access.c lpspi_irq.c lpspi_master_driver.c lpspi_shared_function.c lpspi_slave_driver.c
    ../platform/drivers/src/lptmr/: lptmr_driver.c lptmr_hw_access.c
    ../platform/drivers/src/ftm/: ftm_mc_driver.c ftm_common.c ftm_hw_access.c ftm_pwm_driver.c
    ../platform/drivers/src/adc/: adc_driver.c
  group Generated_Code
    ../Generated_Code/: clockMan1.c pin_mux.c lpuart0.c lpuart1.c lpuart2.c lpi2c0.c lpspiCom1.c lpspiCom0.c lpspiCom2.c lpTmr0.c dmaController1.c flexTimer_mc1.c adConv1.c
  group drivers
    ../Drivers/: lpuart.c i2c.c spi.c gpio_port.c timer.c rtc_pca8565.c IS25LP032_flash.c IAM_20680HT.C ads1278_imu.c
  group APP
    ../App/: main_task.c uart_service.c ie_task.c quick_sort.c signal_process.c
  group CMSIS-DSP
    ../CMSIS-DSP/1.14.2/Source/FilteringFunctions/: arm_fir_init_f32.c arm_fir_f32.c
    ../CMSIS-DSP/1.14.2/Source/TransformFunctions/: arm_rfft_fast_f32.c arm_rfft_fast_init_f32.c arm_cfft_f32.c arm_cfft_init_f32.c arm_bitreversal2.c arm_cfft_radix8_f32.c
    ../CMSIS-DSP/1.14.2/Source/CommonTables/: arm_const_structs.c arm_common_tables.c
    ../CMSIS-DSP/1.14.2/Source/ComplexMathFunctions/: arm_cmplx_mag_f32.c
  group common
    ../common/: fir_config.c iir_lowpass_filter.c iir_highpass_filter.c lib.c
